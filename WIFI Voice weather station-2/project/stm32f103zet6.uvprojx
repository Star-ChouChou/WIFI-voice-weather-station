# Keil uVision project stm32f103zet6.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103zet6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=68 --diag_suppress=111 --diag_suppress=550
  c include: ..\user;..\starup;..\user\api;..\LIB\inc;..\LVGL;..\LVGL_APP;..\LVGL\lv_examples-v6.0;..\LVGL\lvgl_driver;..\LVGL\lvgl-v6.0
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ../user/: stm32f10x_it.c system_stm32f10x.c main.c
  group starup
    ../starup/: startup_stm32f10x_hd.s
  group api
    ../user/api/: delay.c led.c beep.c key.c rtc.c usart1.c bsp_lcd.c ESP8266.c cJSON.c pic.c zi.c spi_flash.c useled.c my1680.c dht11.c lcdshowtask.c adc.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group LVGL
    ../LVGL/lvgl-v6.0/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../LVGL/lvgl-v6.0/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ../LVGL/lvgl-v6.0/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
    ../LVGL/lvgl-v6.0/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../LVGL/lvgl-v6.0/src/lv_misc/: lv_anim.c lv_area.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ../LVGL/lvgl-v6.0/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ../LVGL/lvgl-v6.0/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group LVGL_APP
    ../LVGL_APP/: lv_tutorial_hello_world.c font1.c lvgltask1.c cloudy.c wifi.c location.c yunduan.c styleseetting1.c font2.c qing.c baoyu.c shangxiafanjiantou.c wenduji.c shiduji.c guangzhaoqiangdu.c kongqizhiliang.c dianchi.c xiaotu1.c xiaotu2.c xiaotu3.c yin.c zhenyu.c zhongyu.c dayu.c duoyun.c leizhenyu.c xiaoyu.c interface3img.c youjiantou.c zuojiantou.c font3.c
  group lvgl_driver
    ../LVGL/lvgl_driver/: lv_port_disp.c
software components: CMSIS:CORE 5.2.0
